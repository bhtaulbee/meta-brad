SUMMARY = "Add appfreenove-car-app to Qt image"
IMAGE_INSTALL:prepend := "freenove-car-app"
